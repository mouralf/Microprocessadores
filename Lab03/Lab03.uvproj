# Keil uVision project Lab03.uvproj, settings and files
target Target 1 (MCS-51)
  device: 8031AH Intel
  cpu: IRAM(0-0x7F) CLOCK(12000000)
  output: Lab03
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: Luizinho_e_Pedro_Barros_16x2.c
