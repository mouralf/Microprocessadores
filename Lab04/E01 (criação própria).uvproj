# Keil uVision project E01 (criação própria).uvproj, settings and files
target Target 1 (MCS-51)
  device: 8031AH Intel
  cpu: IRAM(0-0x7F) CLOCK(12000000)
  output: E01 (criação própria) +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: Main.c LCDeca.h Codigo_site.c
